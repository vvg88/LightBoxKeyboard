# Keil uVision project fw_034_2015_keyboard.uvprojx, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RD STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fw_034_2015_keyboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./src/: main.c devinit.c Utils.c CommHandlers.c ItHandlers.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
